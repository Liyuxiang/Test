# Keil uVision project loca_proj.uvproj, settings and files
target VCP (ARM-ADS)
  device: STM32F105RC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: VCP
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c include: ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32_USB_Device_Library\Class\cdc\inc;..\Libraries\STM32_USB_Device_Library\Core\inc;..\Libraries\STM32_USB_OTG_Driver\inc;..\VCP\inc;..\VCP\test
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group vcp
    ../VCP/src/: usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
  group USB Driver
    ../Libraries/STM32_USB_OTG_Driver/src/: usb_dcd_int.c usb_core.c usb_dcd.c
  group USB Device
    ../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../Libraries/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group STM32F10x_StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_flash.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_exti.c misc.c stm32f10x_spi.c stm32f10x_usart.c
  group CMSIS
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group vcp_test
    ../VCP/test/: main.c stm32f10x_it.c
  group os
    ../OS/: os_driver.c
    ../OS/uC-CPU/Cortex-M3/RealView/: cpu_a.asm cpu_c.c
    ../OS/uCOS-II/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu_a.asm os_cpu_c.c os_dbg.c
    ../OS/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group decadriver
    ../decadriver/: deca_device.c deca_params_init.c deca_range_tables.c
  group app
    ../app/: app.c ranging.c stm32f10x_it.c
  group bsp
    ../bsp/: bsp.c decahard.c
target ranging (ARM-ADS)
  device: STM32F105RC STMicroelectronics
  cpu: as above
  output: ranging +hex
  c flags: wLevel=2
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c include: ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32_USB_Device_Library\Class\cdc\inc;..\Libraries\STM32_USB_Device_Library\Core\inc;..\Libraries\STM32_USB_OTG_Driver\inc;..\VCP\inc;..\OS\uC-CPU;..\OS\uC-CPU\Cortex-M3\RealView;..\OS\uCOS-II\Ports\ARM-Cortex-M3\Generic\RealView;..\OS\uCOS-II\Source;..\decadriver;..\app;..\locaplat;..\bsp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
